# Keil uVision project base_ao.uvproj, settings and files
target blinky_ao (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: base_ao
  c flags: Optim=1
  c define: QF_TICK
  c include: ..\..\mcb2300\include;..\qmbsp;C:\qm\qpc\ports\arm7tdmi\Keil\inc;C:\qm\qpc\qep\source;C:\qm\qpc\qf\source;C:\qm\qpc\include;.\src\includes
  asm misc: --predefine "REMAP SETL {TRUE}"  --predefine "RAM_MODE SETL {TRUE}"
  library: MicroLIB
  memory RVCT4: ROM 0x40000000 size 0x4fff
  memory RVCT9: RAM 0x40005000 size 0x2fff
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  link misc: --entry 0x40000000
  group startup
    ../../mcb2300/startup/: swi_interrup.s startup.s
  group retarget
    ../../mcb2300/retarget/: Retarget.c
  group qeplib
    C:/qm/qpc/qep/source/: qep.c qfsm_dis.c qfsm_ini.c qhsm_dis.c qhsm_in.c qhsm_ini.c qhsm_top.c
  group qflib
    C:/qm/qpc/qf/source/: qa_defer.c qa_fifo.c qa_get_.c qa_lifo.c qa_sub.c qa_usub.c qa_usuba.c qeq_fifo.c qeq_get.c qeq_init.c qeq_lifo.c qf_act.c qf_gc.c qf_log2.c qf_new.c qf_pool.c qf_psini.c qf_pspub.c qf_pwr2.c qf_tick.c qmp_get.c qmp_init.c qmp_put.c qte_arm.c qte_ctor.c qte_darm.c qte_rarm.c qvanilla.c
  group src
    ./src/: ad_ao.c coffeemachine_ao.c events.c menu_ao.c push_button2.c rtosbasicmain.c settime_ao.c
  group bsp
    ../qmbsp/: qmbsp.c
  group drivers
    ../../mcb2300/drivers/: Serial.c LCD_4bit.c QEP_timer.c
    ./src/drivers/: rtc.c led.c
target simulation (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: as above
  output: base_ao
  c flags: Optim=1
  c define: QF_TICK
  c include: ..\..\mcb2300\include;..\qmbsp;C:\qm\qpc\ports\arm7tdmi\Keil\inc;C:\qm\qpc\qep\source;C:\qm\qpc\qf\source;C:\qm\qpc\include
  asm misc: as above
  library: MicroLIB
  memory RVCT4: ROM 0x40000000 size 0x3fff
  memory RVCT9: RAM 0x40004000 size 0x3fff
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  link misc: --entry 0x40000000
