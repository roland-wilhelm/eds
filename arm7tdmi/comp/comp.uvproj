# Keil uVision project comp.uvproj, settings and files
target comp (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: comp
  c flags: Optim=1
  c define: QEP QM_ActiveObject QF_TICK
  c include: ..\qmbsp;..\..\mcb2300\include;C:\qm\qpc\include;C:\qm\qpc\ports\arm7tdmi\Keil\inc
  asm misc: --predefine "REMAP SETL {TRUE}"  --predefine "RAM_MODE SETL {TRUE}"
  library: MicroLIB
  memory RVCT4: ROM 0x40000000 size 0x3fff
  memory RVCT9: RAM 0x40004000 size 0x3fff
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  link misc: --entry 0x40000000
  group startup
    ../../mcb2300/startup/: startup.s swi_interrup.s
    ../../mcb2300/retarget/: Retarget.c
  group drivers
    ../../mcb2300/drivers/: LCD_4bit.c Serial.c QEP_timer.c
  group app
    ./src/: alarm.c comp.c
  group compbsp
    ../qmbsp/: qmbsp.c
  group qmlibs
    C:/qm/qpc/ports/arm7tdmi/Keil/qep/objs/: qep.lib
    C:/qm/qpc/ports/arm7tdmi/Keil/qf/obj/: qflib.lib
target simulation (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: as above
  output: comp
  c flags: Optim=1
  c define: QEP QM_ActiveObject QF_TICK
  c include: as above
  asm misc: as above
  library: MicroLIB
  memory RVCT4: ROM 0x40000000 size 0x3fff
  memory RVCT9: RAM 0x40004000 size 0x3fff
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  link misc: --entry 0x40000000
