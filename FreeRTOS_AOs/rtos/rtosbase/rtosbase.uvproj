# Keil uVision project rtosbase.uvproj, settings and files
target rtosbase (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: rtosbase
  c flags: Optim=1
  c include: C:\FreeRTOS\FreeRTOSV6.1.1\Source\include;C:\FreeRTOS\FreeRTOSV6.1.1\Ports\ARM7_LPC2300_Keil\include;..\include;C:\qm\qpc\include;C:\qm\qpc\qf\source;C:\qm\qpc\qep\source;C:\qm\qpc\ports\arm7tdmi\rtos\freertos\includes;..\..\..\mcb2300\include
  asm misc: --predefine "REMAP SETL {TRUE}"  --predefine "RAM_MODE SETL {TRUE}"
  memory RVCT4: ROM 0x40000000 size 0x3fff
  memory RVCT9: RAM 0x40006000 size 0x1fff
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  link misc: --entry 0x40000000
  group Port
    C:/FreeRTOS/FreeRTOSV6.1.1/Ports/ARM7_LPC2300_Keil/: port.c portASM.s
  group FreeRTOSBase
    C:/FreeRTOS/FreeRTOSV6.1.1/Source/: list.c queue.c tasks.c
    C:/FreeRTOS/FreeRTOSV6.1.1/Source/portable/MemMang/: heap_2.c
  group app
    ./src/app/: bsp.c rtosbasicmain.c ad_ao.c coffeemachine_ao.c events.c menu_ao.c settime_ao.c push_button2.c
  group QEP
    C:/qm/qpc/qep/source/: qep.c qfsm_dis.c qfsm_ini.c qhsm_dis.c qhsm_in.c qhsm_ini.c qhsm_top.c
  group QF
    C:/qm/qpc/qf/source/: qa_sub.c qa_usub.c qa_usuba.c qeq_fifo.c qeq_get.c qeq_init.c qeq_lifo.c qf_act.c qf_gc.c qf_log2.c qf_new.c qf_pool.c qf_psini.c qf_pspub.c qf_pwr2.c qf_tick.c qmp_get.c qmp_init.c qmp_put.c qte_arm.c qte_ctor.c qte_darm.c
  group startup
    C:/FreeRTOS/FreeRTOSV6.1.1/Ports/ARM7_LPC2300_Keil/startup/: LPC2300.s
    ../../../mcb2300/retarget/: Retarget.c
  group drivers
    ../../../mcb2300/drivers/: ethsram.c LCD_4bit.c Serial.c
    ./src/drivers/: led.c rtc.c
  group QF_FreeRT_Port
    C:/qm/qpc/ports/arm7tdmi/rtos/freertos/src/: qf_port.c
target simulation (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: as above
  output: rtosbase
  c flags: Optim=1
  c include: as above
  asm misc: as above
  memory RVCT4: ROM 0x40000000 size 0x5fff
  memory RVCT9: RAM 0x40006000 size 0x1fff
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  link misc: --entry 0x40000000
